# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, RT_USING_LIBC, __FPU_PRESENT=1, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, DATA_SECTION_IS_CACHEABLE=1, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: applications;rt-thread\components\net\at\include;rt-thread\components\net\at\at_socket;packages\at_device-master\inc;packages\at_device-master\class\esp32;packages\cJSON-v1.0.2;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\MCUX_Config;board\ports;libraries\drivers;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\legacy;rt-thread\components\legacy\dfs;libraries\MIMXRT1060\CMSIS\Include;libraries\MIMXRT1060\MIMXRT1060;libraries\MIMXRT1060\MIMXRT1060\drivers;libraries\peripherals;packages\LVGL-v8.3.0\src;packages\LVGL-v8.3.0\src\core;packages\LVGL-v8.3.0\src\draw;packages\LVGL-v8.3.0\src\extra;packages\LVGL-v8.3.0\src\font;packages\LVGL-v8.3.0\src\hal;packages\LVGL-v8.3.0\src\misc;packages\LVGL-v8.3.0\src\widgets;packages\LVGL-v8.3.0\src\draw\arm2d;packages\LVGL-v8.3.0\src\draw\nxp;packages\LVGL-v8.3.0\src\draw\sdl;packages\LVGL-v8.3.0\src\draw\stm32_dma2d;packages\LVGL-v8.3.0\src\draw\sw;packages\LVGL-v8.3.0\src\draw\swm341_dma2d;packages\LVGL-v8.3.0\src\draw\nxp\pxp;packages\LVGL-v8.3.0\src\draw\nxp\vglite;packages\LVGL-v8.3.0\src\extra\layouts;packages\LVGL-v8.3.0\src\extra\libs;packages\LVGL-v8.3.0\src\extra\others;packages\LVGL-v8.3.0\src\extra\themes;packages\LVGL-v8.3.0\src\extra\widgets;packages\LVGL-v8.3.0\src\extra\layouts\flex;packages\LVGL-v8.3.0\src\extra\layouts\grid;packages\LVGL-v8.3.0\src\extra\libs\bmp;packages\LVGL-v8.3.0\src\extra\libs\ffmpeg;packages\LVGL-v8.3.0\src\extra\libs\freetype;packages\LVGL-v8.3.0\src\extra\libs\fsdrv;packages\LVGL-v8.3.0\src\extra\libs\gif;packages\LVGL-v8.3.0\src\extra\libs\png;packages\LVGL-v8.3.0\src\extra\libs\qrcode;packages\LVGL-v8.3.0\src\extra\libs\rlottie;packages\LVGL-v8.3.0\src\extra\libs\sjpg;packages\LVGL-v8.3.0\src\extra\others\fragment;packages\LVGL-v8.3.0\src\extra\others\gridnav;packages\LVGL-v8.3.0\src\extra\others\ime;packages\LVGL-v8.3.0\src\extra\others\imgfont;packages\LVGL-v8.3.0\src\extra\others\monkey;packages\LVGL-v8.3.0\src\extra\others\msg;packages\LVGL-v8.3.0\src\extra\others\snapshot;packages\LVGL-v8.3.0\src\extra\themes\basic;packages\LVGL-v8.3.0\src\extra\themes\default;packages\LVGL-v8.3.0\src\extra\themes\mono;packages\LVGL-v8.3.0\src\extra\widgets\animimg;packages\LVGL-v8.3.0\src\extra\widgets\calendar;packages\LVGL-v8.3.0\src\extra\widgets\chart;packages\LVGL-v8.3.0\src\extra\widgets\colorwheel;packages\LVGL-v8.3.0\src\extra\widgets\imgbtn;packages\LVGL-v8.3.0\src\extra\widgets\keyboard;packages\LVGL-v8.3.0\src\extra\widgets\led;packages\LVGL-v8.3.0\src\extra\widgets\list;packages\LVGL-v8.3.0\src\extra\widgets\menu;packages\LVGL-v8.3.0\src\extra\widgets\meter;packages\LVGL-v8.3.0\src\extra\widgets\msgbox;packages\LVGL-v8.3.0\src\extra\widgets\span;packages\LVGL-v8.3.0\src\extra\widgets\spinbox;packages\LVGL-v8.3.0\src\extra\widgets\spinner;packages\LVGL-v8.3.0\src\extra\widgets\tabview;packages\LVGL-v8.3.0\src\extra\widgets\tileview;packages\LVGL-v8.3.0\src\extra\widgets\win;applications\lvgl\demo;applications\lvgl;packages\LVGL-v8.3.0\env_support\rt-thread;applications\lvgl\squareline\ui;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket;packages\tcpserver-latest;rt-thread\components\utilities\ulog;rt-thread\components\utilities\ulog\backend;xip;packages\zFTP-latest\inc;packages\zFTP-master\inc;.\packages\cJSON-latest;.\packages\netutils-master\ntp;.\packages\umqtt-v1.0.0\inc;.\rt-thread\components\dfs\filesystems\ramfs;.\packages\webclient-v2.2.0\inc
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)--entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: main.c
    ./packages/netutils-master/ntp/: ntp.c
    ./applications/: udp_server.c zFTP_test.c image_alram_set.c image_device_info.c image_ray.c image_remote_up.c img_hand.c lock.c lv_font_siyuanheiti_20.c lvgl_sn_interface.c send_mail.c utl_base64.c umqtt_sample.c alarm_timer.c httpclient_sample.c
  group AT
    rt-thread/components/net/at/at_socket/: at_socket.c
    rt-thread/components/net/at/src/: at_utils.c at_client.c at_cli.c
  group at_device
    packages/at_device-master/class/esp32/: at_socket_esp32.c at_device_esp32.c
    packages/at_device-master/src/: at_device.c
    packages/at_device-master/samples/: at_sample_esp32.c
  group cJSON
    ./packages/cJSON-latest/: cJSON_Utils.c cJSON.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/cputime/: cputime.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c dcd.c pin_mux.c
    board/: board.c
    board/ports/: touchpad.c
    libraries/drivers/: drv_gpio.c drv_i2c.c drv_lcd.c drv_uart.c
  group Filesystem
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ./rt-thread/components/dfs/filesystems/ramfs/: dfs_ramfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    libraries/MIMXRT1060/MIMXRT1060/arm/: startup_MIMXRT1062.s
    libraries/MIMXRT1060/MIMXRT1060/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_common_arm.c fsl_elcdif.c fsl_gpio.c fsl_gt911.c fsl_lpi2c.c fsl_lpuart.c fsl_pxp.c fsl_video_common.c fsl_xbara.c fsl_xbarb.c
    libraries/MIMXRT1060/MIMXRT1060/: system_MIMXRT1062.c
  group LVGL
    packages/LVGL-v8.3.0/src/draw/sdl/: lv_draw_sdl_stack_blur.c lv_draw_sdl_label.c lv_draw_sdl_arc.c lv_draw_sdl_utils.c lv_draw_sdl_bg.c lv_draw_sdl.c lv_draw_sdl_mask.c lv_draw_sdl_composite.c lv_draw_sdl_texture_cache.c lv_draw_sdl_rect.c lv_draw_sdl_layer.c lv_draw_sdl_polygon.c lv_draw_sdl_line.c lv_draw_sdl_img.c
    packages/LVGL-v8.3.0/src/core/: lv_obj_pos.c lv_refr.c lv_obj_scroll.c lv_group.c lv_obj_draw.c lv_event.c lv_disp.c lv_theme.c lv_indev_scroll.c lv_obj_tree.c lv_obj_class.c lv_obj_style.c lv_indev.c lv_obj.c lv_obj_style_gen.c
    packages/LVGL-v8.3.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.0/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.0/src/misc/: lv_txt_ap.c lv_anim_timeline.c lv_utils.c lv_area.c lv_bidi.c lv_async.c lv_color.c lv_fs.c lv_ll.c lv_tlsf.c lv_log.c lv_lru.c lv_math.c lv_templ.c lv_mem.c lv_printf.c lv_gc.c lv_style.c lv_style_gen.c lv_txt.c lv_anim.c lv_timer.c
    packages/LVGL-v8.3.0/src/font/: lv_font_montserrat_12_subpx.c lv_font_montserrat_42.c lv_font_montserrat_28.c lv_font_montserrat_34.c lv_font_montserrat_14.c lv_font_montserrat_44.c lv_font_fmt_txt.c lv_font_montserrat_26.c lv_font_loader.c lv_font_unscii_8.c lv_font.c lv_font_montserrat_30.c lv_font_montserrat_18.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_20.c lv_font_montserrat_48.c lv_font_montserrat_22.c lv_font_montserrat_8.c lv_font_montserrat_12.c lv_font_montserrat_32.c lv_font_simsun_16_cjk.c lv_font_montserrat_24.c lv_font_montserrat_46.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_36.c lv_font_montserrat_16.c lv_font_montserrat_10.c lv_font_montserrat_28_compressed.c lv_font_unscii_16.c
    packages/LVGL-v8.3.0/src/draw/nxp/vglite/: lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c
    packages/LVGL-v8.3.0/src/draw/: lv_draw_arc.c lv_draw_label.c lv_draw_mask.c lv_draw_img.c lv_draw_triangle.c lv_img_buf.c lv_draw_transform.c lv_img_cache.c lv_draw.c lv_draw_layer.c lv_img_decoder.c lv_draw_line.c lv_draw_rect.c
    packages/LVGL-v8.3.0/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_fatfs.c lv_fs_stdio.c lv_fs_posix.c
    packages/LVGL-v8.3.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.0/src/widgets/: lv_arc.c lv_objx_templ.c lv_bar.c lv_textarea.c lv_btnmatrix.c lv_switch.c lv_label.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_table.c lv_slider.c lv_line.c lv_btn.c lv_roller.c lv_img.c
    packages/LVGL-v8.3.0/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.0/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.0/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.0/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    packages/LVGL-v8.3.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.0/src/draw/sw/: lv_draw_sw_line.c lv_draw_sw_transform.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_rect.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_gradient.c lv_draw_sw_layer.c lv_draw_sw_polygon.c lv_draw_sw.c lv_draw_sw_dither.c
    packages/LVGL-v8.3.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.0/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-v8.3.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.0/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.0/src/hal/: lv_hal_disp.c lv_hal_tick.c lv_hal_indev.c
    packages/LVGL-v8.3.0/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.0/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.0/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.0/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.0/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.0/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.0/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.0/src/extra/: lv_extra.c
    packages/LVGL-v8.3.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.0/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.0/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.0/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.0/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.0/src/extra/widgets/tileview/: lv_tileview.c
  group LVGL-demo
    applications/lvgl/demo/: lv_demo.c
    packages/lv_music_demo-v0.3.0/assets/: img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_wave_top.c
    packages/lv_music_demo-v0.3.0/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.0/env_support/rt-thread/: lv_rt_thread_port.c
  group LVGL-SquareLine
    applications/lvgl/squareline/ui/: lv_ui_entry.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group tcpserver
    packages/tcpserver-latest/: tcpserver.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: file_be.c console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
  group xip
    xip/: evkbmimxrt1060_flexspi_nor_config.c fsl_flexspi_nor_boot.c
  group zFTP
    packages/zFTP-latest/src/: zFTP.c
  group umqtt
    ./packages/umqtt-v1.0.0/src/: umqtt.c
    ./packages/umqtt-v1.0.0/src/pkgs/: umqtt_pkgs_decode.c umqtt_pkgs_encode.c
    ./packages/umqtt-v1.0.0/src/trans/: umqtt_transport.c
  group webclient
    ./packages/webclient-v2.2.0/src/: webclient.c webclient_file.c
